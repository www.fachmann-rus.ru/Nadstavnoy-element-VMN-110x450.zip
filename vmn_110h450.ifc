Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-22T16:01:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Alternate UI 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 22 16:01:16 2020 * Host: 43-203-2 * Database: C:\Users\A8AC9~1.ZYA\AppData\Local\Temp\{83D0023D-C71E-453C-957D-0B4A14B3D4A5}\ifc * Database version: 5507 * Database creation date: Tue Sep 22 16:01:14 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 22 16:01:15 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 22 16:01:15 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
Phase: П

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Данные - ADSK_Титул_Год выпуска: 2019
Идентификация - Название организации: Название организации
Прочее - Адрес проекта: Адрес проекта; Дата утверждения проекта: Дата; Заказчик: Заказчик; Категория: Сведения о проекте; Статус проекта: П

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул_Год выпуска: 2019
Идентификация - Название организации: Название организации
Прочее - Категория: Сведения о проекте; Адрес проекта: Адрес проекта; Дата утверждения проекта: Дата; Заказчик: Заказчик; Статус проекта: П

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes; Имя типа: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcFlowTerminal: 110х450, BIMLIB_НадставнойЭлемент_Fachmann_VMN:110х450:259531
In: Этаж 01
Material: Fachmann_ПВХ_Черный
Pset_ManufacturerTypeInformation - Manufacturer: Fachmann
Pset_DistributionFlowElementCommon - Reference: 110х450
Зависимости - Рабочая плоскость: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Отметка по умолчанию: 1219.2 mm
Идентификация - Вариант конструкции: Главная модель; Марка: 26; ADSK_Версия семейства: 1; URL: https://fachmann-rus.ru/; Заголовок OmniClass: Roof Waste Water Drains; Изготовитель: Fachmann; Имя типа: 110х450; Номер OmniClass: 23.70.50.21.24.11; Описание: Надставной элемент VMN (воронка с обжимным металлическим фланцем) могут использоваться как надставной элемент к воронкам VM, VMO любых диаметров в утепленных кровлях с двухуровневой парогидроизоляцией. Манжета предотвращает проникновение ливневых стоков в слой теплоизоляции по месту соединения надставного элемента с воронкой.; Производитель_Контакты: Email: all@fachmann-rus.ru; Тел: 8 (800) 511-07-21; Разработчик_Контакты: support@bimlib.pro
Механизмы - ADSK_Расход жидкости: 0 m3/s; Классификация систем: Не определено; Fachmann_МаксимальныйРасход: 0.282517 m3/s
Прочее - Категория: Сантехнические приборы; Код типа: BIMLIB_НадставнойЭлемент_Fachmann_VMN: 110х450; Семейство: BIMLIB_НадставнойЭлемент_Fachmann_VMN: 110х450; Семейство и типоразмер: BIMLIB_НадставнойЭлемент_Fachmann_VMN: 110х450; Тип: BIMLIB_НадставнойЭлемент_Fachmann_VMN: 110х450; Уровень спецификации: Уровень: Этаж 01; a1: 79 mm; a2: 9 mm; a3: 23 mm; a4: 40 mm; a5: 58 mm; d1: 180 mm; d2: 356 mm; d3: 226 mm; d4: 123 mm; d5: 276 mm; Имя семейства: BIMLIB_НадставнойЭлемент_Fachmann_VMN
Размеры - Объем: 0.00724347 m3; ADSK_Диаметр условный: 110 mm; D_Листоуловитель: 164 mm; Fachmann_ВысотаВыпускногоПатрубка: 430 mm; ДиаметрВодоприемнойВоронки: 110 mm; НадставнойЭлементПоложение: 424.7 mm
Стадии - Стадия возведения: ПРОЕКТ
Данные - ADSK_URL документации изделия: https://kirov.fachmann-rus.ru/upload/iblock/3a1/3a14119eb2edc733ae93b58cb812227a.pdf; ADSK_URL страницы изделия: https://kirov.fachmann-rus.ru/catalog/nadstavnye-elementy/362/; ADSK_Версия Revit: 2017; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: Fachmann; ADSK_Код изделия: 22.21.21.12.1.01.04; ADSK_Количество: 1; ADSK_Марка: VMN 110x450; ADSK_Масса_Текст: 1.4 кг; ADSK_Наименование: Надставной элемент VMN 110x450 (арт. 01.095); ADSK_Наименование краткое: Надставной элемент VMN 110x450
Текст - Fachmann_Артикул: 01.095; Fachmann_МаксимальнаяТемператураВнутреннейПоверхностиВоронки: +55 °С; Fachmann_СрокСлужбы: не менее 50 лет; Fachmann_ТемператураОкружающейСреды: от -50 °С до +90 °С; Fachmann_ТемператураОтводящейЖидкости: не более +85 °С
